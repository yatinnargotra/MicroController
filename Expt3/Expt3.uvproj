# Keil uVision project Expt3.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89x516RD2 SST
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0xFFFF) CLOCK(40000000)
  output: Expt3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    D:/Pranav_32418/: led.c
